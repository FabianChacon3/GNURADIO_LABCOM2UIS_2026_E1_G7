options:
  parameters:
    description: Audio mono PCM16 a 44.1 kHz; control de nivel TX y ruido; visualización de audio y canal; captura WAV de recepción.
    generate_options: qt_gui
    id: QPSK_TX_RX
    output_language: python
    title: Laboratorio 6 - Tx/Rx de audio QPSK
  states: {}

blocks:
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: constelacion_qpsk
  id: variable_constellation
  parameters:
    const_points: tabla_de_verdad_constelacion
    dims: '1'
    normalization: digital.constellation.NO_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 2, 3]'
    type: calcdist
  states: {}
- name: h
  id: variable
  parameters:
    value: '[1]*Sps'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    comment: Desviación/amplitud del ruido complejo agregado antes del receptor.
    label: Amplitud del ruido
    start: '0.0'
    step: '0.01'
    stop: '0.20'
    value: '0.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: sample_rate_audio*4*Sps
  states: {}
- name: sample_rate_audio
  id: variable
  parameters:
    comment: El WAV de entrada debe estar físicamente remuestreado a esta tasa.
    value: '44100'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: '[0.77+0.77j, -0.77+0.77j, -0.77-0.77j, 0.77-0.77j]'
  states: {}
- name: tx_power_db
  id: variable_qtgui_range
  parameters:
    comment: 'Ganancia relativa de amplitud: A=10^(dB/20). No representa vatios calibrados.'
    label: Nivel TX relativo (dB)
    start: '-24'
    step: '1'
    stop: '6'
    value: '0'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: noise_amp
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: sample_rate_audio
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '128'
  states: {}
- name: blocks_float_to_char_0
  id: blocks_float_to_char
  parameters:
    scale: '128'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: Sps
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Control de nivel TX antes del canal
    const: 10**(tx_power_db / 20.0)
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '2'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_wavfile_sink_rx
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    comment: Captura la salida reconstruida para comparar métricas fuera de GNU Radio.
    file: data/resultados/audio_rx_capture.wav
    format: FORMAT_WAV
    samp_rate: sample_rate_audio
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: Requiere audio_demo.wav mono PCM16 remuestreado a sample_rate_audio.
    file: data/entrada/audio_demo.wav
    repeat: 'True'
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constelacion_qpsk
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: Sps
    taps: h
    type: ccf
  states: {}
- name: qtgui_const_sink_x_1_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Constelación RX (símbolos muestreados)"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_audio
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: sample_rate_audio
    fc: '0'
    fftsize: '4096'
    grid: 'True'
    label: Magnitud relativa
    name: '"Espectro del audio de entrada"'
    norm_window: 'True'
    type: float
    update_time: '0.20'
    wintype: window.WIN_HANN
    ymax: '5'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    freqhalf: 'False'
    grid: 'True'
    label: Magnitud relativa (dB)
    name: '"Espectro del canal QPSK"'
    type: complex
    ymax: '5'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_audio
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    label1: Audio mono
    name: '"Audio de entrada (forma de onda)"'
    size: '1024'
    srate: sample_rate_audio
    type: float
    ylabel: Amplitud
    ymax: '1.0'
    ymin: '-1.0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    grid: 'True'
    name: '"Señal compleja en el canal"'
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '2.5'
    ymin: '-2.5'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: p1
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: p1
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_xx_0, '0', virtual_sink_0, '0']
- [blocks_char_to_float_0, '0', audio_sink_0, '0']
- [blocks_char_to_float_0, '0', blocks_wavfile_sink_rx, '0']
- [blocks_float_to_char_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_1_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_0, '1']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_char_to_float_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_char_0, '0']
- [blocks_wavfile_source_0, '0', qtgui_freq_sink_audio, '0']
- [blocks_wavfile_source_0, '0', qtgui_time_sink_audio, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [interp_fir_filter_xxx_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_0_0, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
