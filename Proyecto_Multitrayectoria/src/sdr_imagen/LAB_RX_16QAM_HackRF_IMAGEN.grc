options:
  parameters:
    description: 'Recepcion de imagen por paquetes: sincronia, CRC32 por trama, reensamblado y guardado PNG, EVM, AGC y EQ opcional.'
    generate_options: qt_gui
    id: LAB_RX_16QAM_HackRF_IMAGEN
    output_language: python
    title: LAB RX 16-QAM HackRF - IMAGEN (CRC32 + reensamblado)
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: beta
  id: variable_qtgui_range
  parameters:
    label: Roll-off beta
    start: '0.10'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: const_16qam
  id: variable_constellation
  parameters:
    const_points: tabla_de_verdad_constelacion
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: list(range(16))
    type: calcdist
  states: {}
- name: fc
  id: variable
  parameters:
    comment: 960 MHz, igual al Tx
    value: 960e6
  states: {}
- name: hackrf_rx
  id: variable
  parameters:
    value: '"hackrf=0"'
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    comment: 'Sin aplicacion: AWGN de prueba se controla en el TX. Desactivado.'
    label: Amplitud de ruido AWGN
    start: '0'
    step: '0.001'
    stop: '2.5'
    value: '0'
  states: {state: disabled}
- name: radio_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: beta
    gain: Sps
    ntaps: span*Sps
    samp_rate: samp_rate
    sym_rate: Rs
  states: {}
- name: rx_lna
  id: variable_qtgui_range
  parameters:
    label: Rx IF gain / LNA HackRF (0-40 dB, pasos de 8)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    label: Rx BB gain / VGA HackRF (0-62 dB, pasos de 2)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: tuple(z/math.sqrt(10.0) for z in (-3-3j,-3-1j,-3+3j,-3+1j,-1-3j,-1-1j,-1+3j,-1+1j,3-3j,3-1j,3+3j,3+1j,1-3j,1-1j,1+3j,1+1j))
  states: {}
- name: agc_entrada
  id: analog_agc_xx
  parameters:
    comment: 'AGC1: limite razonable inicial, calibrar segun nivel de RF'
    gain: '1.0'
    max_gain: '500'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: agc_simbolos
  id: analog_agc_xx
  parameters:
    comment: 'AGC2: regular amplitud simbolos; comparar con AGC1'
    gain: '1.0'
    max_gain: '100'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: Sps
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_tx_taps
    type: ccc
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    comment: Estima y corrige el offset de frecuencia de portadora.
    filter_size: '44'
    rolloff: beta
    samps_per_sym: Sps
    type: cc
    w: 2*math.pi/400
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    args: hackrf_rx
    bb_gain0: rx_vga
    comment: Recibe muestras complejas del HackRF con frecuencia y tasa declaradas en este GRC.
    freq0: fc + lo_off
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_lna
    sample_rate: radio_rate
    sync: none
    type: fc32
  states: {}
- name: hz_por_rad
  id: blocks_multiply_const_vxx
  parameters:
    comment: rad/muestra -> Hz
    const: samp_rate/(2*math.pi)
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math; import os
  states: {}
- name: null_float
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: offset_hz
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Offset Tx-Rx corregido (Hz)
    max: '5000'
    min: '-5000'
    name: '"Offset de frecuencia estimado por la FLL"'
    type: float
    unit1: Hz
    update_time: '0.20'
  states: {}
- name: pfb_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: Aplica filtro RRC y recuperacion de temporizacion a SPS muestras por simbolo.
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: firdes.root_raised_cosine(nfilts, nfilts*Sps, 1.0, beta, span*Sps*nfilts)
    type: ccf
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"RX constelacion sin recuperar reloj (diagnostico)"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    comment: Convierte 2 MS/s a 64 kS/s con relacion 4/125.
    decim: '125'
    interp: '4'
    type: ccc
  states: {}
- name: receptor_const
  id: digital_constellation_receiver_cb
  parameters:
    comment: Corrige fase residual y decide indices de simbolo de la constelacion 16-QAM.
    constellation: const_16qam
    fmax: '0.25'
    fmin: '-0.25'
    loop_bw: 2*math.pi/100
    showports: 'True'
  states: {}
- name: rx_const_sincronizada
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"RX constelacion recuperada - portadora y reloj"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rx_desplaza
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_off'
    comment: Traslada digitalmente el canal recibido antes de convertir su tasa.
    decim: '1'
    samp_rate: radio_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: rx_espectro_radio
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: radio_rate
    fc: fc
    fftsize: '8192'
    grid: 'True'
    label1: Rx crudo
    name: '"RX espectro DESPUES del desplazamiento digital"'
    type: complex
  states: {}
- name: rx_imagen
  id: epy_block
  parameters:
    comment: Busca tramas, valida CRC32, ordena paquetes y guarda la imagen reconstruida.
    _source_code: |
      import os
      import struct
      import zlib
      import numpy as np
      from numpy.lib.stride_tricks import sliding_window_view
      from gnuradio import gr

      # ---------------------------------------------------------------------------
      # Protocolo de trama (identico en TX y RX):
      #   [PREAMBULO 64 simbolos] [CUERPO: cabecera 12 B + datos N B + CRC32 4 B,
      #   blanqueado con PRBS, 2 simbolos 16-QAM por byte] [GUARDA 24 simbolos]
      # Cabecera (big endian): seq u16, total u16, ancho u16, alto u16,
      #                        canales u8, bytes_utiles u8, id_imagen u16
      # ---------------------------------------------------------------------------
      PRE_LEN = 64
      GUARD_LEN = 24
      HDR_LEN = 12
      HDR_FMT = '>HHHHBBH'
      MAX_MISMATCH = 8

      # Tabla 16-QAM Gray (Es = 1), igual que el TX
      POINTS = np.asarray((
          -3-3j, -3-1j, -3+3j, -3+1j,
          -1-3j, -1-1j, -1+3j, -1+1j,
           3-3j,  3-1j,  3+3j,  3+1j,
           1-3j,  1-1j,  1+3j,  1+1j
      ), dtype=np.complex64) / np.sqrt(10.0)


      def prng(seed, n, bits):
          """xorshift32 determinista (no depende de la version de numpy)."""
          x = (seed & 0xFFFFFFFF) or 1
          mask = (1 << bits) - 1
          out = np.empty(n, dtype=np.uint8)
          for i in range(n):
              x ^= (x << 13) & 0xFFFFFFFF
              x ^= x >> 17
              x ^= (x << 5) & 0xFFFFFFFF
              out[i] = (x >> 16) & mask
          return out


      PREAMBLE = prng(20261029, PRE_LEN, 4)


      class blk(gr.sync_block):
          """Reconstruye una imagen a partir de tramas 16-QAM con CRC32.

          Entrada 0 = indices de simbolo (puerto 0 del constellation_receiver_cb).
          Entrada 1 = muestras sincronizadas (puerto 4 del constellation_receiver_cb).
          Salidas (float): % de imagen completa, % de tramas con CRC OK, EVM medio (%).
          La imagen se guarda en out_path (PNG) cada save_every paquetes nuevos y al completarse.
          """

          def __init__(self, out_path='data/resultados/rx_imagen.png', payload_len=128, save_every=10):
              gr.sync_block.__init__(self, name='RX imagen: CRC32 + reensamblado',
                                     in_sig=[np.uint8, np.complex64],
                                     out_sig=[np.float32, np.float32, np.float32])
              self.out_path = out_path
              self.payload_len = int(payload_len)
              self.save_every = max(1, int(save_every))
              self.body_len = HDR_LEN + self.payload_len + 4
              self.body_nib = 2 * self.body_len
              self.frame_len = PRE_LEN + self.body_nib + GUARD_LEN
              self.whiten = prng(777123, self.body_len, 8)
              self.indices = np.empty(0, dtype=np.uint8)
              self.samples = np.empty(0, dtype=np.complex64)

              # Mapas de rotacion: simbolo recibido -> simbolo transmitido canonico
              self.rotation_maps = []
              for k in range(4):
                  rotated = POINTS * (1j ** k)
                  self.rotation_maps.append(
                      np.argmin(np.abs(POINTS[:, None] - rotated[None, :]) ** 2,
                                axis=1).astype(np.uint8))

              self.total_frames = 0
              self.crc_ok_frames = 0
              self.evm = -1.0
              self.progress = 0.0
              self.ok_pct = 0.0
              self.last_report = 0
              self.completed_printed = False
              self._reset_image(None)
              print('[RX] Buscando preambulo de %d simbolos (4 rotaciones). '
                    'Salida: %s' % (PRE_LEN, self.out_path))
              print('[RX] payload_len=%d B, trama=%d simbolos. Progreso/EVM = -1 '
                    'hasta decodificar una trama.' % (self.payload_len, self.frame_len))

          # ------------------------------------------------------------------
          def _reset_image(self, key):
              self.key = key
              self.buf = None
              self.have = None
              self.count = 0
              self.unsaved = 0
              self.completed_printed = False

          def _resolve_out_path(self):
              path = self.out_path
              if not os.path.isabs(path):
                  module_path = globals().get('__file__')
                  if module_path:
                      path = os.path.join(os.path.dirname(module_path), path)
              path = os.path.abspath(path)
              os.makedirs(os.path.dirname(path), exist_ok=True)
              return path

          def _save(self):
              if self.buf is None:
                  return
              try:
                  from PIL import Image
                  _, _, w, h, ch, _ = self.key
                  mode = 'RGB' if ch == 3 else 'L'
                  im = Image.frombytes(mode, (w, h), bytes(self.buf[:w * h * ch]))
                  out_path = self._resolve_out_path()
                  base, ext = os.path.splitext(out_path)
                  tmp = base + '_tmp' + (ext or '.png')
                  im.save(tmp)
                  os.replace(tmp, out_path)
                  self.unsaved = 0
              except Exception as e:  # noqa: BLE001
                  print('[RX] No se pudo guardar la imagen:', e)

          def _store(self, hdr, payload):
              seq, total, w, h, ch, real, img_id = hdr
              if total == 0 or w == 0 or h == 0 or ch not in (1, 3) or seq >= total \
                      or real > self.payload_len or total * self.payload_len < w * h * ch:
                  return
              key = (img_id, total, w, h, ch, self.payload_len)
              if key != self.key:
                  self._reset_image(key)
                  self.buf = bytearray(total * self.payload_len)
                  self.have = np.zeros(total, dtype=bool)
                  print('[RX] Nueva imagen detectada: %dx%d, %d canal(es), %d paquetes, id=0x%04X'
                        % (w, h, ch, total, img_id))
              if not self.have[seq]:
                  self.have[seq] = True
                  self.count += 1
                  self.unsaved += 1
                  self.buf[seq * self.payload_len:seq * self.payload_len + real] = payload[:real]
                  self.progress = 100.0 * self.count / total
                  if self.count == total:
                      self._save()
                      if not self.completed_printed:
                          self.completed_printed = True
                          print('[RX] *** IMAGEN COMPLETA (%d/%d paquetes) -> %s'
                                % (self.count, total, self._resolve_out_path()))
                  elif self.unsaved >= self.save_every:
                      self._save()

          # ------------------------------------------------------------------
          def _find_preamble(self):
              n = len(self.indices)
              if n < PRE_LEN:
                  return None, 0
              win = sliding_window_view(self.indices, PRE_LEN)
              mism = np.stack([(lut[win] != PREAMBLE).sum(axis=1)
                               for lut in self.rotation_maps])
              best = mism.min(axis=0)
              cand = np.nonzero(best <= MAX_MISMATCH)[0]
              if len(cand) == 0:
                  return None, n - PRE_LEN + 1
              p = int(cand[0])
              return (p, int(np.argmin(mism[:, p]))), 0

          def _drop(self, k):
              self.indices = self.indices[k:]
              self.samples = self.samples[k:]

          def _process(self):
              while len(self.indices) >= PRE_LEN:
                  found, cut = self._find_preamble()
                  if found is None:
                      self._drop(cut)  # conserva PRE_LEN-1 simbolos
                      return
                  p, rot = found
                  if len(self.indices) - p < self.frame_len:
                      if p:
                          self._drop(p)
                      return  # la trama aun no llego completa
                  ds = p + PRE_LEN
                  de = ds + self.body_nib
                  rec = self.rotation_maps[rot][self.indices[ds:de]]
                  tx = ((rec[0::2] << 4) | rec[1::2]).astype(np.uint8) ^ self.whiten
                  body = tx.tobytes()
                  self.total_frames += 1
                  crc_ok = (struct.unpack('>I', body[-4:])[0] ==
                            (zlib.crc32(body[:-4]) & 0xFFFFFFFF))
                  if crc_ok:
                      self.crc_ok_frames += 1
                      hdr = struct.unpack(HDR_FMT, body[:HDR_LEN])
                      self._store(hdr, body[HDR_LEN:HDR_LEN + self.payload_len])
                      # EVM asistido por datos (simbolos transmitidos ya verificados)
                      rx = self.samples[ds:de].astype(np.complex128)
                      ref = POINTS[rec].astype(np.complex128) * (1j ** rot)
                      coef = np.vdot(ref, rx) / (np.vdot(ref, ref) + 1e-15)
                      est = coef * ref
                      en = np.sum(np.abs(est) ** 2)
                      if en > 1e-12:
                          e = 100.0 * np.sqrt(np.sum(np.abs(rx - est) ** 2) / en)
                          self.evm = e if self.evm < 0 else 0.9 * self.evm + 0.1 * e
                      self._drop(p + self.frame_len)
                  else:
                      # Falsa alarma o trama danada: avanza solo el preambulo
                      self._drop(p + PRE_LEN)
                  self.ok_pct = 100.0 * self.crc_ok_frames / self.total_frames
                  if self.total_frames - self.last_report >= 50 or self.total_frames == 1:
                      self.last_report = self.total_frames
                      print('[RX] tramas=%d CRC_OK=%d (%.1f%%) imagen=%.1f%% EVM=%.2f%% rot=%d'
                            % (self.total_frames, self.crc_ok_frames, self.ok_pct,
                               self.progress, self.evm, rot * 90))

          def work(self, input_items, output_items):
              n = min(len(input_items[0]), len(input_items[1]),
                      *(len(v) for v in output_items))
              if n <= 0:
                  return 0
              self.indices = np.concatenate(
                  (self.indices, np.asarray(input_items[0][:n], dtype=np.uint8)))
              self.samples = np.concatenate(
                  (self.samples, np.asarray(input_items[1][:n], dtype=np.complex64)))
              self._process()
              output_items[0][:n] = self.progress
              output_items[1][:n] = self.ok_pct
              output_items[2][:n] = self.evm
              return n
    out_path: out_path
    payload_len: payload_len
    save_every: save_every
  states: {}
- name: ecualizador_lms_opcional
  id: epy_block
  parameters:
    comment: 0=paso transparente. 1=prueba LMS decision-directed, no usar hasta lograr lock.
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Optional symbol-rate normalized LMS equalizer. Disabled by default.

          Experimental: it makes hard 16-QAM decisions without pilots and therefore
          may FAIL before carrier/AGC convergence. Keep enabled=0 for baseline.
          """
          def __init__(self, enabled=0, mu=0.001, ntaps=7):
              gr.sync_block.__init__(self, name='EQ LMS opcional - desactivado',
                                     in_sig=[np.complex64], out_sig=[np.complex64])
              self.enabled = int(enabled)
              self.mu = float(mu)
              self.ntaps = int(ntaps)
              self.history = np.zeros(self.ntaps, dtype=np.complex64)
              self.weights = np.zeros(self.ntaps, dtype=np.complex64)
              self.weights[self.ntaps // 2] = 1
              self.points = np.asarray((
                  -3-3j, -3-1j, -3+3j, -3+1j,
                  -1-3j, -1-1j, -1+3j, -1+1j,
                   3-3j,  3-1j,  3+3j,  3+1j,
                   1-3j,  1-1j,  1+3j,  1+1j), np.complex64) / np.sqrt(10.0)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n = min(len(inp), len(out))
              if self.enabled == 0:
                  out[:n] = inp[:n]
                  return n
              for i in range(n):
                  self.history[1:] = self.history[:-1]
                  self.history[0] = inp[i]
                  y = np.vdot(self.weights, self.history)
                  out[i] = y
                  target = self.points[np.argmin(np.abs(self.points - y))]
                  error = target - y
                  denom = np.vdot(self.history, self.history).real + 1e-8
                  self.weights += self.mu * np.conjugate(error) * self.history / denom
              return n
    enabled: '0'
    mu: '0.001'
    ntaps: '7'
  states: {}
- name: medidor_progreso
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    comment: Porcentaje de paquetes distintos recibidos con CRC OK
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Progreso
    max: '100'
    min: '0'
    name: '"Imagen recibida (%) [paquetes unicos / total]"'
    type: float
    unit1: '%'
    update_time: '0.20'
  states: {}
- name: medidor_evm
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    comment: EVM asistido por datos en tramas con CRC OK
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: EVM
    max: '150'
    name: '"EVM (%) [ -1 sin trama ]"'
    type: float
    unit1: '%'
    update_time: '0.20'
  states: {}
- name: medidor_crc
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    comment: Tramas con CRC valido / tramas detectadas
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: CRC OK
    max: '100'
    min: '0'
    name: '"Tramas con CRC OK (%)"'
    type: float
    unit1: '%'
    update_time: '0.20'
  states: {}
- name: rx_log_iq_64ksps
  id: epy_block
  parameters:
    comment: Registro opcional IQ relativo al flujo.
    _source_code: |
      import os
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, file_path='data/resultados/registro.bin', item_type='complex'):
              self.dtype = np.complex64 if item_type == 'complex' else np.uint8
              gr.sync_block.__init__(self, name='Registro binario opcional',
                                     in_sig=[self.dtype], out_sig=[])
              self.file_path = file_path
              self.handle = None

          def _open(self):
              path = self.file_path
              if not os.path.isabs(path):
                  module_path = globals().get('__file__')
                  if module_path:
                      path = os.path.join(os.path.dirname(module_path), path)
              path = os.path.abspath(path)
              os.makedirs(os.path.dirname(path), exist_ok=True)
              self.handle = open(path, 'wb')
              print('[RX] Registro binario: %s' % path)

          def work(self, input_items, output_items):
              data = input_items[0]
              if len(data):
                  if self.handle is None:
                      self._open()
                  self.handle.write(np.ascontiguousarray(data, dtype=self.dtype).tobytes())
              return len(data)

          def stop(self):
              if self.handle is not None:
                  self.handle.close()
                  self.handle = None
              return True
    file_path: '''data/resultados/RX_IQ_64ksps.c64'''
    item_type: '''complex'''
  states: {state: disabled}
- name: rx_log_indices_simbolos
  id: epy_block
  parameters:
    comment: Registro opcional de decisiones relativo al flujo.
    _source_code: |
      import os
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          def __init__(self, file_path='data/resultados/registro.bin', item_type='complex'):
              self.dtype = np.complex64 if item_type == 'complex' else np.uint8
              gr.sync_block.__init__(self, name='Registro binario opcional',
                                     in_sig=[self.dtype], out_sig=[])
              self.file_path = file_path
              self.handle = None

          def _open(self):
              path = self.file_path
              if not os.path.isabs(path):
                  module_path = globals().get('__file__')
                  if module_path:
                      path = os.path.join(os.path.dirname(module_path), path)
              path = os.path.abspath(path)
              os.makedirs(os.path.dirname(path), exist_ok=True)
              self.handle = open(path, 'wb')
              print('[RX] Registro binario: %s' % path)

          def work(self, input_items, output_items):
              data = input_items[0]
              if len(data):
                  if self.handle is None:
                      self._open()
                  self.handle.write(np.ascontiguousarray(data, dtype=self.dtype).tobytes())
              return len(data)

          def stop(self):
              if self.handle is not None:
                  self.handle.close()
                  self.handle = None
              return True
    file_path: '''data/resultados/RX_simbolos_decididos.u8'''
    item_type: '''byte'''
  states: {state: disabled}
- name: out_path
  id: variable
  parameters:
    comment: PNG reconstruido dentro de data/resultados al abrir el flujo desde esta carpeta.
    value: '''data/resultados/rx_imagen.png'''
  states: {}
- name: payload_len
  id: variable
  parameters:
    comment: Bytes de imagen por trama. DEBE ser igual al TX
    value: '128'
  states: {}
- name: save_every
  id: variable
  parameters:
    comment: Guardar el PNG cada N paquetes nuevos
    value: '10'
  states: {}

connections:
- [agc_entrada, '0', fll, '0']
- [agc_simbolos, '0', receptor_const, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_const_sink_x_1, '0']
- [ecualizador_lms_opcional, '0', agc_simbolos, '0']
- [fir_filter_xxx_0, '0', blocks_keep_one_in_n_0, '0']
- [fir_filter_xxx_0, '0', qtgui_eye_sink_x_0, '0']
- [fll, '0', pfb_sync, '0']
- [fll, '1', hz_por_rad, '0']
- [hackrf_source, '0', rx_desplaza, '0']
- [hz_por_rad, '0', offset_hz, '0']
- [pfb_sync, '0', ecualizador_lms_opcional, '0']
- [rational_resampler_xxx_0_0, '0', agc_entrada, '0']
- [rational_resampler_xxx_0_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', rx_log_iq_64ksps, '0']
- [receptor_const, '0', rx_log_indices_simbolos, '0']
- [receptor_const, '0', rx_imagen, '0']
- [receptor_const, '1', null_float, '0']
- [receptor_const, '2', null_float, '1']
- [receptor_const, '3', null_float, '2']
- [receptor_const, '4', rx_const_sincronizada, '0']
- [receptor_const, '4', rx_imagen, '1']
- [rx_desplaza, '0', rational_resampler_xxx_0_0, '0']
- [rx_desplaza, '0', rx_espectro_radio, '0']
- [rx_imagen, '0', medidor_progreso, '0']
- [rx_imagen, '1', medidor_evm, '0']
- [rx_imagen, '2', medidor_crc, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
