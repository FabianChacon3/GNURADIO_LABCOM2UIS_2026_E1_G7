options:
  parameters:
    description: Recepcion de tramas conocidas, correlacion 4 rotaciones de fase, CRC32, BER, EVM, controles AGC y EQ opcional.
    generate_options: qt_gui
    id: LAB_RX_16QAM_HackRF_Verificado
    output_language: python
    title: LAB RX 16-QAM HackRF - BER + EVM + CRC + SINCRONIA
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: beta
  id: variable_qtgui_range
  parameters:
    label: Roll-off beta
    start: '0.10'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: const_16qam
  id: variable_constellation
  parameters:
    const_points: tabla_de_verdad_constelacion
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: list(range(16))
    type: calcdist
  states: {}
- name: fc
  id: variable
  parameters:
    comment: 960 MHz, igual al Tx
    value: 960e6
  states: {}
- name: hackrf_rx
  id: variable
  parameters:
    value: '"hackrf=0"'
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    comment: 'Sin aplicacion: AWGN de prueba se controla en el TX. Desactivado.'
    label: Amplitud de ruido AWGN
    start: '0'
    step: '0.001'
    stop: '2.5'
    value: '0'
  states: {state: disabled}
- name: radio_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: beta
    gain: Sps
    ntaps: span*Sps
    samp_rate: samp_rate
    sym_rate: Rs
  states: {}
- name: rx_lna
  id: variable_qtgui_range
  parameters:
    label: Rx IF gain / LNA HackRF (0-40 dB, pasos de 8)
    start: '0'
    step: '8'
    stop: '40'
    value: '16'
  states: {}
- name: rx_vga
  id: variable_qtgui_range
  parameters:
    label: Rx BB gain / VGA HackRF (0-62 dB, pasos de 2)
    start: '0'
    step: '2'
    stop: '62'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: tuple(z/math.sqrt(10.0) for z in (-3-3j,-3-1j,-3+3j,-3+1j,-1-3j,-1-1j,-1+3j,-1+1j,3-3j,3-1j,3+3j,3+1j,1-3j,1-1j,1+3j,1+1j))
  states: {}
- name: agc_entrada
  id: analog_agc_xx
  parameters:
    comment: 'AGC1: limite razonable inicial, calibrar segun nivel de RF'
    gain: '1.0'
    max_gain: '500'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: agc_simbolos
  id: analog_agc_xx
  parameters:
    comment: 'AGC2: regular amplitud simbolos; comparar con AGC1'
    gain: '1.0'
    max_gain: '100'
    rate: '1e-3'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: Sps
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_tx_taps
    type: ccc
  states: {}
- name: fll
  id: digital_fll_band_edge_cc
  parameters:
    comment: Corrige el offset de frecuencia entre radios
    filter_size: '44'
    rolloff: beta
    samps_per_sym: Sps
    type: cc
    w: 2*math.pi/400
  states: {}
- name: hackrf_source
  id: osmosdr_source
  parameters:
    args: hackrf_rx
    bb_gain0: rx_vga
    comment: 'ATENCION: 960MHz solo sistema confinado/autorizado. RX usa LO=fc+200kHz.'
    freq0: fc + lo_off
    gain0: '0'
    gain_mode0: 'False'
    if_gain0: rx_lna
    sample_rate: radio_rate
    sync: none
    type: fc32
  states: {}
- name: hz_por_rad
  id: blocks_multiply_const_vxx
  parameters:
    comment: rad/muestra -> Hz
    const: samp_rate/(2*math.pi)
    type: float
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: null_float
  id: blocks_null_sink
  parameters:
    num_inputs: '3'
    type: float
  states: {}
- name: offset_hz
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    avg: '0.1'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Offset Tx-Rx corregido (Hz)
    max: '5000'
    min: '-5000'
    name: '"Offset de frecuencia estimado por la FLL"'
    type: float
    unit1: Hz
    update_time: '0.20'
  states: {}
- name: pfb_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    comment: Filtro acoplado RRC + recuperacion de reloj
    filter_size: nfilts
    init_phase: nfilts/2
    loop_bw: 2*math.pi/100
    max_dev: '1.5'
    osps: '1'
    sps: Sps
    taps: firdes.root_raised_cosine(nfilts, nfilts*Sps, 1.0, beta, span*Sps*nfilts)
    type: ccf
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    name: '"RX constelacion sin recuperar reloj (diagnostico)"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_eye_sink_x_0
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    samp_per_symbol: Sps
    size: '1024'
    srate: samp_rate
    type: complex
    ymax: '10'
    ymin: '-10'
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '125'
    interp: '4'
    type: ccc
  states: {}
- name: receptor_const
  id: digital_constellation_receiver_cb
  parameters:
    comment: Corrige fase residual y decide simbolos
    constellation: const_16qam
    fmax: '0.25'
    fmin: '-0.25'
    loop_bw: 2*math.pi/100
    showports: 'True'
  states: {}
- name: rx_const_sincronizada
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"RX constelacion recuperada - portadora y reloj"'
    size: '1024'
    type: complex
    xmax: '1.5'
    xmin: '-1.5'
    ymax: '1.5'
    ymin: '-1.5'
  states: {}
- name: rx_desplaza
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_off'
    decim: '1'
    samp_rate: radio_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: rx_espectro_radio
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    average: '0.2'
    bw: radio_rate
    fc: fc
    fftsize: '8192'
    grid: 'True'
    label1: Rx crudo
    name: '"RX espectro DESPUES del desplazamiento digital"'
    type: complex
  states: {}
- name: rx_medidor_tramas
  id: epy_block
  parameters:
    comment: Detecta preambulo, remueve giros 0/90/180/270, CRC, BER acumulada, EVM (datos conocidos).
    _source_code: |
      import numpy as np
      import zlib
      from gnuradio import gr

      # 16-QAM Gray-indexed table, average symbol energy Es = 1.
      POINTS = np.asarray((
          -3-3j, -3-1j, -3+3j, -3+1j,
          -1-3j, -1-1j, -1+3j, -1+1j,
           3-3j,  3-1j,  3+3j,  3+1j,
           1-3j,  1-1j,  1+3j,  1+1j
      ), dtype=np.complex64) / np.sqrt(10.0)
      PRE_LEN = 64
      PAY_LEN = 48
      GUARD_LEN = 24
      PAYLOAD = b"LAB GNU RADIO 16QAM HACKRF 2026".ljust(PAY_LEN, b" ")
      # Seed is fixed; TX and RX use the same deterministic preamble.
      PREAMBLE = np.random.default_rng(20261029).integers(0, 16, PRE_LEN, dtype=np.uint8)
      GUARD = np.random.default_rng(160116).integers(0, 16, GUARD_LEN, dtype=np.uint8)
      CRC = zlib.crc32(PAYLOAD).to_bytes(4, 'big')
      PACKET = PAYLOAD + CRC
      PACKET_NIB = np.empty(2 * len(PACKET), dtype=np.uint8)
      PACKET_NIB[0::2] = np.frombuffer(PACKET, dtype=np.uint8) >> 4
      PACKET_NIB[1::2] = np.frombuffer(PACKET, dtype=np.uint8) & 15
      FRAME = np.concatenate((PREAMBLE, PACKET_NIB, GUARD)).astype(np.uint8)


      class blk(gr.sync_block):
          """Decode known frames; show BER, EVM and verified frame rate.

          Input 0 = symbol indices from constellation_receiver_cb port 0.
          Input 1 = synchronized, carrier-corrected samples from port 4.
          Outputs = float32 BER percentage, EVM percentage, valid frame percentage.
          """
          def __init__(self):
              gr.sync_block.__init__(self, name='RX tramas: BER EVM CRC32',
                                     in_sig=[np.uint8, np.complex64],
                                     out_sig=[np.float32, np.float32, np.float32])
              self.pattern = FRAME[:PRE_LEN]
              self.samples = np.empty(0, dtype=np.complex64)
              self.indices = np.empty(0, dtype=np.uint8)
              self.frame_len = len(FRAME)
              self.data_len = len(PACKET_NIB)
              self.total_frames = 0
              self.valid_frames = 0
              self.bit_errors = 0
              self.bit_total = 0
              self.metric_ber = -1.0
              self.metric_evm = -1.0
              self.metric_ok = 0.0
              self.evm_accum = 0.0
              self.hamming = np.array([bin(x).count('1') for x in range(16)], dtype=np.uint8)
              # For each ambiguity angle, rotated RX symbol -> canonical TX symbol.
              self.rotation_maps = []
              for k in range(4):
                  rotated = POINTS * (1j ** k)
                  self.rotation_maps.append(np.argmin(np.abs(POINTS[:, None] - rotated[None, :])**2,
                                                      axis=1).astype(np.uint8))
              self.last_report = 0
              print('[RX] Searching 64-symbol preamble, 4 possible quarter-turn rotations.')
              print('[RX] BER/EVM = -1 means no fully decoded frame yet.')

          def _process(self):
              # Max 8 wrong preamble indices gives low false-alarm probability.
              while len(self.indices) >= PRE_LEN:
                  nstart = len(self.indices) - PRE_LEN + 1
                  found = None
                  for p in range(nstart):
                      rxpre = self.indices[p:p+PRE_LEN]
                      for rot, lut in enumerate(self.rotation_maps):
                          mismatch = int(np.count_nonzero(lut[rxpre] != self.pattern))
                          if mismatch <= 8:
                              found = (p, rot)
                              break
                      if found is not None:
                          break
                  if found is None:
                      # Keep last PRE_LEN-1 indices for preambles spanning work() calls.
                      cut = nstart
                      self.indices = self.indices[cut:]
                      self.samples = self.samples[cut:]
                      break
                  p, rot = found
                  if len(self.indices) - p < self.frame_len:
                      if p:
                          self.indices = self.indices[p:]
                          self.samples = self.samples[p:]
                      break  # Full frame has not yet arrived.
                  data_start = p + PRE_LEN
                  data_end = data_start + self.data_len
                  recovered = self.rotation_maps[rot][self.indices[data_start:data_end]]
                  raw = np.bitwise_or(recovered[0::2] << 4, recovered[1::2]).astype(np.uint8).tobytes()
                  payload = raw[:PAY_LEN]
                  rx_crc = raw[PAY_LEN:PAY_LEN+4]
                  crc_ok = (zlib.crc32(payload).to_bytes(4, 'big') == rx_crc)
                  verified = crc_ok and payload == PAYLOAD
                  bit_errors = int(np.sum(self.hamming[np.bitwise_xor(recovered, PACKET_NIB)]))
                  self.bit_errors += bit_errors
                  self.bit_total += self.data_len * 4
                  self.total_frames += 1
                  if verified:
                      self.valid_frames += 1
                  self.metric_ber = 100.0 * self.bit_errors / max(self.bit_total, 1)
                  self.metric_ok = 100.0 * self.valid_frames / self.total_frames
                  # Data-aided EVM, with estimated complex scalar channel gain/phase.
                  # It uses the *known transmitted symbols*, including erroneous decisions.
                  rx_samples = self.samples[data_start:data_end].astype(np.complex128)
                  reference = POINTS[PACKET_NIB].astype(np.complex128) * (1j ** rot)
                  coefficient = np.vdot(reference, rx_samples) / (np.vdot(reference, reference) + 1e-15)
                  estimate = coefficient * reference
                  energy = np.sum(np.abs(estimate) ** 2)
                  if energy > 1e-12:
                      evm = 100.0 * np.sqrt(np.sum(np.abs(rx_samples - estimate)**2) / energy)
                      self.evm_accum += float(evm)
                      self.metric_evm = self.evm_accum / self.total_frames
                  if self.total_frames == 1 or self.total_frames - self.last_report >= 50:
                      print('[RX] frames=%d ok=%d (%.1f%%), BER=%.4f%%, EVM=%.2f%%, rot=%d, CRC=%s, mensaje=%s' % (
                          self.total_frames, self.valid_frames, self.metric_ok, self.metric_ber,
                          self.metric_evm, rot * 90, 'OK' if crc_ok else 'ERROR',
                          payload.decode('ascii', errors='replace').strip()))
                      self.last_report = self.total_frames
                  # Discard processed frame; the guard is inside it.
                  end = p + self.frame_len
                  self.indices = self.indices[end:]
                  self.samples = self.samples[end:]

          def work(self, input_items, output_items):
              n = min(len(input_items[0]), len(input_items[1]),
                      *(len(v) for v in output_items))
              if n <= 0:
                  return 0
              self.indices = np.concatenate((self.indices, np.asarray(input_items[0][:n], dtype=np.uint8)))
              self.samples = np.concatenate((self.samples, np.asarray(input_items[1][:n], dtype=np.complex64)))
              self._process()
              output_items[0][:n] = self.metric_ber
              output_items[1][:n] = self.metric_evm
              output_items[2][:n] = self.metric_ok
              return n
  states: {}
- name: ecualizador_lms_opcional
  id: epy_block
  parameters:
    comment: 0=paso transparente. 1=prueba LMS decision-directed, no usar hasta lograr lock.
    _source_code: |-
      import numpy as np
      from gnuradio import gr

      class blk(gr.sync_block):
          """Optional symbol-rate normalized LMS equalizer. Disabled by default.

          Experimental: it makes hard 16-QAM decisions without pilots and therefore
          may FAIL before carrier/AGC convergence. Keep enabled=0 for baseline.
          """
          def __init__(self, enabled=0, mu=0.001, ntaps=7):
              gr.sync_block.__init__(self, name='EQ LMS opcional - desactivado',
                                     in_sig=[np.complex64], out_sig=[np.complex64])
              self.enabled = int(enabled)
              self.mu = float(mu)
              self.ntaps = int(ntaps)
              self.history = np.zeros(self.ntaps, dtype=np.complex64)
              self.weights = np.zeros(self.ntaps, dtype=np.complex64)
              self.weights[self.ntaps // 2] = 1
              self.points = np.asarray((
                  -3-3j, -3-1j, -3+3j, -3+1j,
                  -1-3j, -1-1j, -1+3j, -1+1j,
                   3-3j,  3-1j,  3+3j,  3+1j,
                   1-3j,  1-1j,  1+3j,  1+1j), np.complex64) / np.sqrt(10.0)

          def work(self, input_items, output_items):
              inp = input_items[0]
              out = output_items[0]
              n = min(len(inp), len(out))
              if self.enabled == 0:
                  out[:n] = inp[:n]
                  return n
              for i in range(n):
                  self.history[1:] = self.history[:-1]
                  self.history[0] = inp[i]
                  y = np.vdot(self.weights, self.history)
                  out[i] = y
                  target = self.points[np.argmin(np.abs(self.points - y))]
                  error = target - y
                  denom = np.vdot(self.history, self.history).real + 1e-8
                  self.weights += self.mu * np.conjugate(error) * self.history / denom
              return n
    enabled: '0'
    mu: '0.001'
    ntaps: '7'
  states: {}
- name: medidor_ber
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    comment: Metrica basada en preambulo conocido; sin trama BER/EVM=-1
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Offset Tx-Rx corregido (Hz)
    max: '100'
    name: '"BER acumulada (%) [ -1 sin trama ]"'
    type: float
    unit1: Hz
    update_time: '0.20'
  states: {}
- name: medidor_evm
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    comment: Metrica basada en preambulo conocido; sin trama BER/EVM=-1
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Offset Tx-Rx corregido (Hz)
    max: '150'
    name: '"EVM media (%) [ -1 sin trama ]"'
    type: float
    unit1: Hz
    update_time: '0.20'
  states: {}
- name: medidor_tramas
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    comment: Metrica basada en preambulo conocido; sin trama BER/EVM=-1
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: Offset Tx-Rx corregido (Hz)
    max: '100'
    name: '"Tramas verificadas (%) - CRC + mensaje"'
    type: float
    unit1: Hz
    update_time: '0.20'
  states: {}
- name: rx_log_iq_64ksps
  id: blocks_file_sink
  parameters:
    comment: 'CAPTURA OPCIONAL: habilitar manualmente; archivo binario; cuidado con el tamano'
    type: complex
    file: '''/mnt/data/RX_IQ_64ksps.c64'''
  states: {state: disabled}
- name: rx_log_indices_simbolos
  id: blocks_file_sink
  parameters:
    comment: 'CAPTURA OPCIONAL: habilitar manualmente; archivo binario; cuidado con el tamano'
    type: byte
    file: '''/mnt/data/RX_simbolos_decididos.u8'''
  states: {state: disabled}

connections:
- [agc_entrada, '0', fll, '0']
- [agc_simbolos, '0', receptor_const, '0']
- [blocks_keep_one_in_n_0, '0', qtgui_const_sink_x_1, '0']
- [ecualizador_lms_opcional, '0', agc_simbolos, '0']
- [fir_filter_xxx_0, '0', blocks_keep_one_in_n_0, '0']
- [fir_filter_xxx_0, '0', qtgui_eye_sink_x_0, '0']
- [fll, '0', pfb_sync, '0']
- [fll, '1', hz_por_rad, '0']
- [hackrf_source, '0', rx_desplaza, '0']
- [hz_por_rad, '0', offset_hz, '0']
- [pfb_sync, '0', ecualizador_lms_opcional, '0']
- [rational_resampler_xxx_0_0, '0', agc_entrada, '0']
- [rational_resampler_xxx_0_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0_0, '0', rx_log_iq_64ksps, '0']
- [receptor_const, '0', rx_log_indices_simbolos, '0']
- [receptor_const, '0', rx_medidor_tramas, '0']
- [receptor_const, '1', null_float, '0']
- [receptor_const, '2', null_float, '1']
- [receptor_const, '3', null_float, '2']
- [receptor_const, '4', rx_const_sincronizada, '0']
- [receptor_const, '4', rx_medidor_tramas, '1']
- [rx_desplaza, '0', rational_resampler_xxx_0_0, '0']
- [rx_desplaza, '0', rx_espectro_radio, '0']
- [rx_medidor_tramas, '0', medidor_ber, '0']
- [rx_medidor_tramas, '1', medidor_evm, '0']
- [rx_medidor_tramas, '2', medidor_tramas, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
