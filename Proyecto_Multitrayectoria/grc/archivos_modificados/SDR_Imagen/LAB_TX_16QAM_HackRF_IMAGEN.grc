options:
  parameters:
    description: Transmision ciclica de una imagen en paquetes con cabecera + CRC32, 16QAM Gray Es=1; 8ksym/s, 2MS/s. Radio solo en RF confinada/frecuencia autorizada.
    generate_options: qt_gui
    id: LAB_TX_16QAM_HackRF_IMAGEN
    output_language: python
    title: LAB TX 16-QAM HackRF - IMAGEN (tramas + CRC32)
  states: {}

blocks:
- name: M
  id: variable
  parameters:
    value: len(tabla_de_verdad_constelacion)
  states: {}
- name: Rb
  id: variable
  parameters:
    value: Rs*bps
  states: {}
- name: Rs
  id: variable
  parameters:
    value: '8000'
  states: {}
- name: Sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: beta
  id: variable_qtgui_range
  parameters:
    label: Roll-off beta
    start: '0.10'
    step: '0.05'
    stop: '1.0'
    value: '0.5'
  states: {}
- name: bps
  id: variable
  parameters:
    value: int(math.log(M,2))
  states: {}
- name: const_16qam
  id: variable_constellation
  parameters:
    const_points: tabla_de_verdad_constelacion
    dims: '1'
    normalization: digital.constellation.POWER_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: list(range(16))
    type: calcdist
  states: {}
- name: fc
  id: variable
  parameters:
    comment: 960 MHz
    value: 960e6
  states: {}
- name: hackrf_tx
  id: variable
  parameters:
    value: '"hackrf=0"'
  states: {}
- name: lo_off
  id: variable
  parameters:
    value: 200e3
  states: {}
- name: noise_amp
  id: variable_qtgui_range
  parameters:
    label: AWGN digital (0=desactivado) - RF confinada
    start: '0'
    step: '0.001'
    stop: '0.2'
    value: '0'
  states: {}
- name: radio_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: rrc_tx_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: beta
    gain: Sps
    ntaps: span*Sps
    samp_rate: samp_rate
    sym_rate: Rs
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: Rs*Sps
  states: {}
- name: span
  id: variable
  parameters:
    value: '11'
  states: {}
- name: tabla_de_verdad_constelacion
  id: variable
  parameters:
    value: tuple(z/math.sqrt(10.0) for z in (-3-3j,-3-1j,-3+3j,-3+1j,-1-3j,-1-1j,-1+3j,-1+1j,3-3j,3-1j,3+3j,3+1j,1-3j,1-1j,1+3j,1+1j))
  states: {}
- name: tx_amp
  id: variable_qtgui_range
  parameters:
    label: Amplitud digital Tx (pico < 1)
    start: '0.01'
    step: '0.01'
    stop: '1.0'
    value: '0.15'
  states: {}
- name: tx_vga
  id: variable_qtgui_range
  parameters:
    label: Tx IF gain HackRF (0-47 dB)
    start: '0'
    step: '1'
    stop: '47'
    value: '20'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    comment: Convierte los indices de simbolo 0 a 15 en puntos de la tabla 16-QAM.
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: tabla_de_verdad_constelacion
  states: {}
- name: hackrf_sink
  id: osmosdr_sink
  parameters:
    args: hackrf_tx
    bb_gain0: '0'
    comment: Entrega la se?al compleja al HackRF con los valores de radio declarados en este GRC.
    freq0: fc - lo_off
    gain0: '0'
    if_gain0: tx_vga
    sample_rate: radio_rate
    sync: none
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math; import os
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: '"Salida del canal + AWGN"'
    legend: 'False'
    name: '"TX muestras RRC (NO decisiones de simbolo)"'
    size: '2048'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    label1: Tx despues de RRC
    name: '"TX espectro banda base antes del HackRF"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: I
    label2: Q
    name: '"Envolvente compleja Tx (antes de escalar)"'
    size: '2048'
    srate: samp_rate
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: Convierte 64 kS/s a 2 MS/s con relacion 125/4.
    decim: '4'
    interp: '125'
    type: ccc
  states: {}
- name: rrc_tx
  id: interp_fir_filter_xxx
  parameters:
    comment: Conforma e interpola los simbolos con el filtro RRC configurado.
    interp: Sps
    taps: rrc_tx_taps
    type: ccf
  states: {}
- name: tx_desplaza
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-lo_off'
    comment: Traslada digitalmente la se?al a la frecuencia intermedia configurada.
    decim: '1'
    samp_rate: radio_rate
    taps: '[1]'
    type: ccc
  states: {}
- name: tx_escala
  id: blocks_multiply_const_vxx
  parameters:
    comment: Escala digitalmente la envolvente antes de la suma de ruido.
    const: tx_amp
    type: complex
  states: {}
- name: tx_imagen
  id: epy_block
  parameters:
    comment: Convierte la imagen real a bytes y genera tramas 16-QAM con preambulo, cabecera, CRC32 y guarda. test_mode es falso por defecto.
    test_mode: 'False'
    _source_code: |
      import os
      import struct
      import zlib
      import numpy as np
      from gnuradio import gr

      # ---------------------------------------------------------------------------
      # Protocolo de trama (identico en TX y RX):
      #   [PREAMBULO 64 simbolos] [CUERPO: cabecera 12 B + datos N B + CRC32 4 B,
      #   blanqueado con PRBS, 2 simbolos 16-QAM por byte] [GUARDA 24 simbolos]
      # Cabecera (big endian): seq u16, total u16, ancho u16, alto u16,
      #                        canales u8, bytes_utiles u8, id_imagen u16
      # La imagen se repite ciclicamente: el RX reconstruye aunque pierda paquetes.
      # ---------------------------------------------------------------------------
      PRE_LEN = 64
      GUARD_LEN = 24
      HDR_LEN = 12
      HDR_FMT = '>HHHHBBH'


      def prng(seed, n, bits):
          """xorshift32 determinista (no depende de la version de numpy)."""
          x = (seed & 0xFFFFFFFF) or 1
          mask = (1 << bits) - 1
          out = np.empty(n, dtype=np.uint8)
          for i in range(n):
              x ^= (x << 13) & 0xFFFFFFFF
              x ^= x >> 17
              x ^= (x << 5) & 0xFFFFFFFF
              out[i] = (x >> 16) & mask
          return out

      PREAMBLE = prng(20261029, PRE_LEN, 4)
      GUARD = prng(160116, GUARD_LEN, 4)

      def resolve_image_path(path):
          if os.path.isabs(path):
              return path
          module_path = globals().get('__file__')
          base = os.path.dirname(module_path) if module_path else os.getcwd()
          return os.path.abspath(os.path.join(base, path))

      def load_image(path, w, h, ch, test_mode=False):
          from PIL import Image, ImageDraw

          mode = 'RGB' if ch == 3 else 'L'
          resolved = resolve_image_path(path) if path else ''
          if resolved and os.path.isfile(resolved):
              with Image.open(resolved) as source:
                  if source.mode in ('RGBA', 'LA', 'P'):
                      source = source.convert('RGBA')
                      fondo = Image.new('RGBA', source.size, (255, 255, 255, 255))
                      source = Image.alpha_composite(fondo, source)
                  im = source.convert(mode).resize((w, h), Image.LANCZOS)
              print('[TX] Imagen cargada: %s -> %dx%d, %d canal(es)' %
                    (resolved, w, h, ch))
              return im

          if not test_mode:
              raise FileNotFoundError(
                  '[TX] No se encontro el PNG de entrada: %s. '
                  'Corrige image_path o activa test_mode solo para una prueba.'
                  % (resolved or str(path))
              )

          print('[TX] MODO PRUEBA explicito: se genera un patron sintetico.')
          im = Image.new('RGB', (w, h), (255, 255, 255))
          d = ImageDraw.Draw(im)
          colores = [(255, 0, 0), (0, 160, 0), (0, 0, 255),
                     (255, 200, 0), (0, 0, 0)]
          bw = max(1, w // len(colores))
          for i, c in enumerate(colores):
              d.rectangle([i * bw, 0, (i + 1) * bw - 1, h // 2], fill=c)
          if w > 2 and h > 2:
              x0 = min(2, w - 1)
              x1 = max(x0, w - 3)
              y0 = min(h - 1, h // 2 + 1)
              d.rectangle([x0, y0, x1, h - 1], outline=(0, 0, 0))
          d.text((min(8, w - 1), min(h // 2 + 2, h - 1)),
                 'PRUEBA 16-QAM', fill=(0, 0, 0))
          return im.convert(mode)

      class blk(gr.sync_block):
          """Transmite ciclicamente una imagen como tramas de indices 16-QAM (0..15)."""

          def __init__(self, image_path='../../../figures/escenario/Logouis.png',
                       width=160, height=80, channels=3, payload_len=128,
                       test_mode=False):
              gr.sync_block.__init__(self, name='TX imagen: tramas + CRC32',
                                     in_sig=None, out_sig=[np.uint8])
              self.image_path = image_path
              self.test_mode = bool(test_mode)
              self.width = int(width)
              self.height = int(height)
              self.channels = 3 if int(channels) == 3 else 1
              self.payload_len = int(payload_len)
              if not (1 <= self.payload_len <= 255):
                  raise ValueError('payload_len debe estar entre 1 y 255')
              if self.width > 65535 or self.height > 65535:
                  raise ValueError('ancho/alto demasiado grandes')

              self.frame_all = None
              self.position = 0

          def _prepare_frames(self):
              im = load_image(self.image_path, self.width, self.height,
                              self.channels, self.test_mode)
              data = im.tobytes()
              img_id = zlib.crc32(data) & 0xFFFF
              plen = self.payload_len
              npk = (len(data) + plen - 1) // plen
              whiten = prng(777123, HDR_LEN + plen + 4, 8)

              frames = []
              for seq in range(npk):
                  chunk = data[seq * plen:(seq + 1) * plen]
                  real = len(chunk)
                  chunk = chunk.ljust(plen, b'\x00')
                  hdr = struct.pack(HDR_FMT, seq, npk, self.width, self.height,
                                    self.channels, real, img_id)
                  body = hdr + chunk
                  body += struct.pack('>I', zlib.crc32(body) & 0xFFFFFFFF)
                  tx = np.frombuffer(body, dtype=np.uint8) ^ whiten
                  nib = np.empty(2 * len(tx), dtype=np.uint8)
                  nib[0::2] = tx >> 4
                  nib[1::2] = tx & 15
                  frames.append(np.concatenate((PREAMBLE, nib, GUARD)))
              self.frame_all = np.concatenate(frames).astype(np.uint8)
              print('[TX] %d bytes -> %d paquetes de %d B; trama = %d simbolos; '
                    'ciclo completo = %d simbolos (~%.1f s a 8 ksym/s); id=0x%04X'
                    % (len(data), npk, plen, len(frames[0]), len(self.frame_all),
                       len(self.frame_all) / 8000.0, img_id))

          def work(self, input_items, output_items):
              if self.frame_all is None:
                  self._prepare_frames()
              out = output_items[0]
              n = len(out)
              if n < 1:
                  return 0
              L = len(self.frame_all)
              pos = (self.position + np.arange(n, dtype=np.int64)) % L
              out[:] = self.frame_all[pos]
              self.position = (self.position + n) % L
              return n
    image_path: image_path
    width: img_width
    height: img_height
    channels: img_channels
    payload_len: payload_len
  states: {}
- name: awgn_prueba
  id: analog_noise_source_x
  parameters:
    comment: Solo para pruebas controladas. Desactivar con noise_amp=0.
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: noise_amp
    seed: '0'
  states: {}
- name: sumar_awgn
  id: blocks_add_xx
  parameters:
    comment: Suma ruido AWGN digital; noise_amp inicia en cero.
    type: complex
  states: {}
- name: tx_iq_a_hackrf
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: Visualiza las muestras I/Q digitales que llegan al sink, no una medicion RF calibrada.
    grid: 'True'
    label1: I
    label2: Q
    name: '"TX I/Q realmente enviados a HackRF (2 MSps)"'
    size: '1024'
    srate: radio_rate
    type: complex
    ymax: '5'
    ymin: '-5'
  states: {}
- name: image_path
  id: variable
  parameters:
    comment: Ruta relativa a este GRC; se resuelve al ejecutar el flujo.
    value: '''../../../figures/escenario/Logouis.png'''
  states: {}
- name: img_width
  id: variable
  parameters:
    comment: Ancho en pixeles a transmitir
    value: '160'
  states: {}
- name: img_height
  id: variable
  parameters:
    comment: Alto en pixeles a transmitir
    value: '80'
  states: {}
- name: img_channels
  id: variable
  parameters:
    comment: 3 = RGB, 1 = escala de grises (3x mas rapido)
    value: '3'
  states: {}
- name: payload_len
  id: variable
  parameters:
    comment: Bytes de imagen por trama. DEBE ser igual en el RX
    value: '128'
  states: {}

connections:
- [awgn_prueba, '0', sumar_awgn, '1']
- [digital_chunks_to_symbols_xx_0, '0', rrc_tx, '0']
- [rational_resampler_xxx_0, '0', tx_desplaza, '0']
- [rrc_tx, '0', qtgui_const_sink_x_0, '0']
- [rrc_tx, '0', qtgui_freq_sink_x_0, '0']
- [rrc_tx, '0', qtgui_time_sink_x_0, '0']
- [rrc_tx, '0', tx_escala, '0']
- [sumar_awgn, '0', rational_resampler_xxx_0, '0']
- [tx_desplaza, '0', hackrf_sink, '0']
- [tx_desplaza, '0', tx_iq_a_hackrf, '0']
- [tx_escala, '0', sumar_awgn, '0']
- [tx_imagen, '0', digital_chunks_to_symbols_xx_0, '0']

metadata:
  file_format: 1
  grc_version: v3.10.11.0-89-ga17f69e7
